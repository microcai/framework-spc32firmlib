# Keil uVision project Project.uvproj, settings and files
target FWLib (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Libraries\CMSIS\cm3;..\..\..\..\Libraries\CMSIS\device;..\..\..\..\Libraries\drivers\inc;..\..\..\..\Libraries\drivers\inc\reg;..\..\..\..\Utilities
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../: main.c isr.c driver_i2c.c
  group Periph_Driver
    ../../../../Libraries/drivers/src/: adc.c aes.c clock.c comp.c crc.c ecap.c flash.c global.c gpio.c i2c.c misc.c pga.c power.c pwm.c ssp.c timer.c uart.c wdt.c
  group CMSIS
    ../../../../Libraries/CMSIS/cm3/: core_cm3.c
    ../../../../Libraries/CMSIS/device/: system_spc1068.c
    ../../../../Libraries/CMSIS/device/startup/arm/: startup_spc1068.s
  group Utilities
    ../../../../Utilities/: delay.c retarget.c
