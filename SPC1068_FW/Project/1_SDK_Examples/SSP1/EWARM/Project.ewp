# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Libraries\CMSIS\cm3; ..\..\..\..\Libraries\CMSIS\device; ..\..\..\..\Libraries\drivers\inc\reg; ..\..\..\..\Libraries\drivers\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: spc1068.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Libraries/CMSIS/cm3/: core_cm3.c
    ../../../../Libraries/CMSIS/device/startup/iar/: startup_spc1068.s
    ../../../../Libraries/CMSIS/device/: system_spc1068.c
  group Periph_Driver
    ../../../../Libraries/drivers/src/: adc.c aes.c clock.c comp.c crc.c ecap.c flash.c global.c gpio.c i2c.c misc.c pga.c power.c pwm.c ssp.c timer.c uart.c wdt.c
  group User
    ../: isr.c main.c
  group Utilities
    ../../../../Utilities/: delay.c retarget.c
